// SPDX-License-Identifier: GPL-2.0-or-later
#pragma once

#include <obs.hpp>
#include <obs-frontend-api.h>
#include <util/dstr.h>
#include <graphics/vec2.h>
#include <array>
#include <memory>
#include <functional>
#include <string>
#include <vector>
#include <mutex>
#include <deque>
#include <algorithm>
#include <cmath>
#include <cstdint>
#include "freemix-audio.hpp"

class MixEffectManager {
public:
	struct IndependentMix {
		std::string previewUuid, programUuid;
		std::string transitionUuid;
		std::string transitionName;
		uint32_t width = 720, height = 1280;
		bool fill = true;
		double positionX = 0.5, positionY = 0.5, zoom = 1.0;
		OBSSourceAutoRelease transition;
		bool activeLease = false;
		std::shared_ptr<MixAudioTape> stingerTape;
		std::vector<std::unique_ptr<MixStingerTap>> stingerTaps;
		OBSSceneAutoRelease proxy;
		obs_sceneitem_t *proxyItem = nullptr;
		OBSSignal proxyRemoved;

		IndependentMix() : stingerTape(std::make_shared<MixAudioTape>()) {}
		IndependentMix(const IndependentMix&) = delete;
		IndependentMix& operator=(const IndependentMix&) = delete;
		IndependentMix(IndependentMix&&) = default;
		IndependentMix& operator=(IndependentMix&&) = default;
	};

	std::array<IndependentMix, 3> independentMixes;
	std::function<bool(obs_source_t*)> IsPrivateSource;
	std::function<bool(uint32_t)> outputBusy;
	std::function<std::string()> ConfigPath;

	void RefreshStingerTaps(IndependentMix& mix) {
		if (!mix.transition || std::string(obs_source_get_id(mix.transition)) != "obs_stinger_transition") return;
		obs_source_enum_full_tree(mix.transition, [](obs_source_t* parent, obs_source_t* child, void* param) {
			auto& mix = *static_cast<IndependentMix*>(param);
			if (parent != static_cast<obs_source_t*>(mix.transition) || std::string(obs_source_get_id(child)) != "ffmpeg_source") return;
			OBSDataAutoRelease settings = obs_source_get_settings(child);
			if (!obs_data_get_bool(settings, "is_stinger")) return;
obs_source_set_audio_mixers(child, 0);
		obs_source_set_muted(child, true);
#pragma warning(push)
#pragma warning(disable: 4996)
		obs_source_set_monitoring_type(child, OBS_MONITORING_TYPE_NONE);
#pragma warning(pop)
			for (const auto& tap : mix.stingerTaps)
				if (static_cast<obs_source_t*>(tap->source) == child) return;
			auto tap = std::make_unique<MixStingerTap>();
			tap->source = obs_source_get_ref(child);
			tap->tape = mix.stingerTape;
			obs_source_add_audio_capture_callback(child, CaptureStingerAudio, tap.get());
			mix.stingerTaps.push_back(std::move(tap));
		}, &mix);
	}

	void ClearIndependentTransition(IndependentMix& mix) {
		for (auto& tap : mix.stingerTaps)
			obs_source_remove_audio_capture_callback(tap->source, CaptureStingerAudio, tap.get());
		mix.stingerTaps.clear();
		std::lock_guard<std::mutex> lock(mix.stingerTape->mutex);
		mix.stingerTape->packets.clear();
		mix.stingerTape->clockStarted = false;
		if (mix.transition) {
			if (mix.activeLease) obs_source_dec_active(mix.transition);
			obs_transition_clear(mix.transition);
		}
		mix.activeLease = false;
		mix.transition = nullptr;
		if (mix.proxy && mix.proxyItem) {
			obs_sceneitem_remove(mix.proxyItem);
			mix.proxyItem = nullptr;
		}
	}

	std::string ProxyName(uint32_t mixId) { return std::string("PGM M/E ") + std::to_string(mixId); }

	static void OnProxyRemoved(void* data, calldata_t*) {
		auto& mix = *static_cast<IndependentMix*>(data);
		mix.proxyItem = nullptr;
		mix.proxy = nullptr;
		mix.proxyRemoved.Disconnect();
	}

	void EnsurePublicProxy(IndependentMix& mix, uint32_t mixId) {
		if (!mix.proxy) {
			const std::string proxyName = ProxyName(mixId);
			OBSSourceAutoRelease existing = obs_get_source_by_name(proxyName.c_str());
			if (existing && obs_source_get_type(existing) == OBS_SOURCE_TYPE_SCENE && !IsPrivateSource(existing)) {
				mix.proxy = OBSSceneAutoRelease{ obs_scene_get_ref(obs_scene_from_source(existing)) };
				std::vector<obs_sceneitem_t*> stale;
				obs_scene_enum_items(mix.proxy, [](obs_scene_t*, obs_sceneitem_t* item, void* param) {
					static_cast<std::vector<obs_sceneitem_t*>*>(param)->push_back(item);
					return true;
				}, &stale);
				for (auto* item : stale) obs_sceneitem_remove(item);
			} else {
				mix.proxy = OBSSceneAutoRelease{ obs_scene_create(proxyName.c_str()) };
			}
			mix.proxyItem = nullptr;
			mix.proxyRemoved.Connect(obs_source_get_signal_handler(obs_scene_get_source(mix.proxy)), "remove", OnProxyRemoved, &mix);
		}
		if (!mix.transition) return;
		if (mix.proxyItem && obs_sceneitem_get_source(mix.proxyItem) == static_cast<obs_source_t*>(mix.transition)) return;
		if (mix.proxyItem) { obs_sceneitem_remove(mix.proxyItem); mix.proxyItem = nullptr; }
		mix.proxyItem = obs_scene_add(mix.proxy, mix.transition);
		if (mix.proxyItem) {
			vec2 scale; vec2_set(&scale, 1.0f, 1.0f);
			vec2 position; vec2_set(&position, 0.0f, 0.0f);
			obs_sceneitem_set_scale(mix.proxyItem, &scale);
			obs_sceneitem_set_pos(mix.proxyItem, &position);
			obs_sceneitem_set_bounds_type(mix.proxyItem, OBS_BOUNDS_SCALE_INNER);
			obs_sceneitem_set_bounds_alignment(mix.proxyItem, OBS_ALIGN_CENTER);
			obs_video_info canvas{}; const bool hasCanvas = obs_get_video_info(&canvas) && canvas.base_width && canvas.base_height;
			vec2 bounds; vec2_set(&bounds, float(hasCanvas ? canvas.base_width : mix.width), float(hasCanvas ? canvas.base_height : mix.height));
			obs_sceneitem_set_bounds(mix.proxyItem, &bounds);
			if (hasCanvas && (canvas.base_width != mix.width || canvas.base_height != mix.height))
				obs_sceneitem_set_scale_filter(mix.proxyItem, OBS_SCALE_BILINEAR);
		}
	}

	OBSSourceAutoRelease FrameMixSource(IndependentMix& mix, obs_source_t* source) {
		if (!source || IsPrivateSource(source)) return nullptr;
		const auto sw = obs_source_get_width(source), sh = obs_source_get_height(source);
		if (!sw || !sh) return nullptr;
		const std::string frameName = std::string("3Mix mix frame ") + obs_source_get_uuid(source);
		const bool moving = mix.transition && std::string(obs_source_get_id(mix.transition)) == "move_transition";
		obs_scene_t* original = obs_scene_from_source(source);
		obs_scene_t* scene = moving && original ? obs_scene_duplicate(original, frameName.c_str(), OBS_SCENE_DUP_PRIVATE_REFS) : obs_scene_create_private(frameName.c_str());
		if (!scene) return nullptr;
		OBSDataAutoRelease dimensions = obs_source_get_settings(obs_scene_get_source(scene));
		std::vector<obs_transform_info> originalTransforms;
		if (moving && original) {
			OBSDataArrayAutoRelease items = obs_data_array_create();
			struct SavedItems { obs_data_array_t* items; std::vector<obs_transform_info>* transforms; } saved{ items, &originalTransforms };
			obs_scene_enum_items(scene, [](obs_scene_t*, obs_sceneitem_t* item, void* param) {
				auto& saved = *static_cast<SavedItems*>(param);
				obs_sceneitem_save(item, saved.items);
				obs_transform_info info; obs_sceneitem_get_info2(item, &info);
				saved.transforms->push_back(info);
				return true;
			}, &saved);
			obs_data_set_array(dimensions, "items", items);
		}
		obs_data_set_bool(dimensions, "custom_size", true);
		obs_data_set_int(dimensions, "cx", mix.width);
		obs_data_set_int(dimensions, "cy", mix.height);
		obs_source_load(obs_scene_get_source(scene));
		const float factor = float(mix.zoom) * (mix.fill ? std::max(float(mix.width) / sw, float(mix.height) / sh) : std::min(float(mix.width) / sw, float(mix.height) / sh));
		vec2 scale, position; vec2_set(&scale, factor, factor);
		vec2_set(&position, (float(mix.width) - sw * factor) * float(mix.positionX), (float(mix.height) - sh * factor) * float(mix.positionY));
		if (moving && original) {
			struct Geometry { float factor; vec2 offset; std::vector<obs_transform_info>* transforms; size_t next = 0; } geometry{ factor, position, &originalTransforms };
			obs_scene_enum_items(scene, [](obs_scene_t*, obs_sceneitem_t* item, void* param) {
				auto& g = *static_cast<Geometry*>(param);
				if (g.next >= g.transforms->size()) return false;
				obs_transform_info info = (*g.transforms)[g.next++];
				info.pos.x = info.pos.x * g.factor + g.offset.x;
				info.pos.y = info.pos.y * g.factor + g.offset.y;
				info.scale.x *= g.factor;
				info.scale.y *= g.factor;
				info.bounds.x *= g.factor;
				info.bounds.y *= g.factor;
				obs_sceneitem_set_info2(item, &info);
				return true;
			}, &geometry);
		} else {
			obs_sceneitem_t* item = obs_scene_add(scene, source);
			obs_sceneitem_set_scale(item, &scale);
			obs_sceneitem_set_pos(item, &position);
			obs_sceneitem_set_alignment(item, OBS_ALIGN_LEFT | OBS_ALIGN_TOP);
		}
		OBSSourceAutoRelease framed = obs_source_get_ref(obs_scene_get_source(scene));
		obs_scene_release(scene);
		return framed;
	}

	std::string TransitionUuidByName(const std::string& name) {
		std::string found;
		if (name.empty()) return found;
		obs_frontend_source_list list = {};
		obs_frontend_get_transitions(&list);
		for (size_t n = 0; n < list.sources.num; n++) {
			obs_source_t* t = list.sources.array[n];
			if (name == obs_source_get_name(t)) { found = obs_source_get_uuid(t); break; }
		}
		obs_frontend_source_list_free(&list);
		return found;
	}

	bool TransitionUuidUsable(const std::string& uuid) {
		OBSSourceAutoRelease source = obs_get_source_by_uuid(uuid.c_str());
		return source && obs_source_get_type(source) == OBS_SOURCE_TYPE_TRANSITION && !IsPrivateSource(source);
	}

	void ResolveMixTransition(IndependentMix& mix) {
		if (mix.transition || mix.transitionUuid.empty() || mix.transitionUuid == "builtin:move_transition" || TransitionUuidUsable(mix.transitionUuid)) return;
		const std::string current = TransitionUuidByName(mix.transitionName);
		if (current.empty()) mix.transitionName.clear();
		mix.transitionUuid = current;
	}

	bool EnsureIndependentMix(IndependentMix& mix, uint32_t mixId) {
		if (mix.transition) { RefreshStingerTaps(mix); EnsurePublicProxy(mix, mixId); return true; }
		ResolveMixTransition(mix);
		if (mix.transitionUuid.empty()) {
			mix.transition = obs_source_create_private("fade_transition", "3Mix Mix 2", nullptr);
		} else if (mix.transitionUuid == "builtin:move_transition") {
			OBSDataAutoRelease settings = obs_data_create(); obs_data_set_bool(settings, "nested_scenes", true);
			mix.transition = obs_source_create_private("move_transition", "3Mix Merge", settings);
		} else {
			OBSSourceAutoRelease original = obs_get_source_by_uuid(mix.transitionUuid.c_str());
			if (!original || obs_source_get_type(original) != OBS_SOURCE_TYPE_TRANSITION || IsPrivateSource(original)) return false;
			OBSDataAutoRelease originalSettings = obs_source_get_settings(original), settings = obs_data_create(); obs_data_apply(settings, originalSettings);
			const bool stinger = std::string(obs_source_get_id(original)) == "obs_stinger_transition";
			if (stinger) obs_data_set_int(settings, "audio_monitoring", OBS_MONITORING_TYPE_NONE);
			mix.transition = obs_source_create_private(obs_source_get_id(original), "3Mix Mix 2", settings);
			if (stinger && mix.transition) {
				obs_source_set_audio_mixers(mix.transition, 0);
				obs_audio_info info; if (!obs_get_audio_info(&info)) return false;
				mix.stingerTape->rate = info.samples_per_sec; mix.stingerTape->channels = get_audio_channels(info.speakers);
				RefreshStingerTaps(mix);
			}
		}
		if (!mix.transition) return false;
		obs_transition_set_size(mix.transition, mix.width, mix.height);
		obs_transition_set_scale_type(mix.transition, OBS_TRANSITION_SCALE_STRETCH);
		OBSSourceAutoRelease source = obs_get_source_by_uuid(mix.programUuid.c_str());
		OBSSourceAutoRelease framed = FrameMixSource(mix, source);
		if (framed) obs_transition_set(mix.transition, framed);
		EnsurePublicProxy(mix, mixId);
		return true;
	}

	void DescribeMix(obs_data_t* response, IndependentMix& mix, uint32_t mixId) {
		if (mix.transition && obs_transition_is_active(mix.transition) && obs_transition_get_time(mix.transition) >= 1.0f) {
			OBSSourceAutoRelease source = obs_get_source_by_uuid(mix.programUuid.c_str());
			OBSSourceAutoRelease framed = FrameMixSource(mix, source);
			if (framed) obs_transition_set(mix.transition, framed);
			if (mix.activeLease) { obs_source_dec_active(mix.transition); mix.activeLease = false; }
		}
		obs_data_set_int(response, "mixId", mixId);
		obs_data_set_int(response, "stingerAudioSources", (int)mix.stingerTaps.size());
		{ std::lock_guard<std::mutex> lock(mix.stingerTape->mutex); obs_data_set_int(response, "stingerAudioPackets", (int)mix.stingerTape->capturedPackets); obs_data_set_double(response, "stingerAudioPeak", mix.stingerTape->capturedPeak); obs_data_set_int(response, "stingerAudioTimestamp", mix.stingerTape->packets.empty() ? 0 : (int)mix.stingerTape->packets.back().timestamp); }
		obs_data_set_string(response, "previewUuid", mix.previewUuid.c_str());
		obs_data_set_string(response, "programUuid", mix.programUuid.c_str());
		obs_data_set_int(response, "width", mix.width); obs_data_set_int(response, "height", mix.height);
		obs_data_set_bool(response, "fill", mix.fill);
		obs_data_set_double(response, "positionX", mix.positionX); obs_data_set_double(response, "positionY", mix.positionY); obs_data_set_double(response, "zoom", mix.zoom);
		obs_data_set_string(response, "transitionUuid", mix.transitionUuid.c_str()); obs_data_set_string(response, "transitionName", mix.transitionName.c_str());
		obs_data_set_string(response, "proxyUuid", mix.proxy ? obs_source_get_uuid(obs_scene_get_source(mix.proxy)) : "");
		OBSDataArrayAutoRelease available = obs_data_array_create();
		const char* transitionId; for (size_t n = 0; obs_enum_transition_types(n, &transitionId); n++) if (std::string(transitionId) == "move_transition") {
			OBSDataAutoRelease item = obs_data_create(); obs_data_set_string(item, "uuid", "builtin:move_transition"); obs_data_set_string(item, "name", "Merge \xC2\xB7 movimento de fontes (Move)"); obs_data_set_string(item, "kind", transitionId); obs_data_array_push_back(available, item);
		}
		obs_frontend_source_list transitions = {}; obs_frontend_get_transitions(&transitions);
		for (size_t i = 0; i < transitions.sources.num; i++) {
			obs_source_t* source = transitions.sources.array[i]; if (IsPrivateSource(source)) continue;
			OBSDataAutoRelease item = obs_data_create(); obs_data_set_string(item, "uuid", obs_source_get_uuid(source)); obs_data_set_string(item, "name", obs_source_get_name(source)); obs_data_set_string(item, "kind", obs_source_get_id(source)); obs_data_array_push_back(available, item);
		}
		obs_frontend_source_list_free(&transitions); obs_data_set_array(response, "transitions", available);
		obs_data_set_bool(response, "transitioning", mix.transition && obs_transition_is_active(mix.transition));
	}

	void DescribeMixes(obs_data_t* response) {
		OBSDataArrayAutoRelease mixes = obs_data_array_create();
		for (size_t i = 0; i < independentMixes.size(); i++) {
			OBSDataAutoRelease item = obs_data_create(); DescribeMix(item, independentMixes[i], uint32_t(i + 2)); if (i == 0) obs_data_apply(response, item); obs_data_array_push_back(mixes, item);
		}
		obs_data_set_array(response, "mixes", mixes);
	}

	void RequestMix(obs_data_t* request, obs_data_t* response, void*) {
		const std::string action = obs_data_get_string(request, "action"), uuid = obs_data_get_string(request, "uuid");
		const auto width = uint32_t(obs_data_get_int(request, "width")), height = uint32_t(obs_data_get_int(request, "height"));
		const auto duration = uint32_t(obs_data_get_int(request, "duration"));
		const bool fill = obs_data_get_bool(request, "fill");
		const uint32_t mixId = obs_data_has_user_value(request, "mixId") ? uint32_t(obs_data_get_int(request, "mixId")) : 2;
		if (mixId < 2 || mixId > 4) { obs_data_set_bool(response, "success", false); obs_data_set_string(response, "error", "select Mix 2, 3 or 4"); return; }
		IndependentMix& mix = independentMixes[mixId - 2];
		ResolveMixTransition(mix);
		DescribeMix(response, mix, mixId);
		std::string error;
		if (action == "configure") {
			const auto positionX = obs_data_has_user_value(request, "positionX") ? obs_data_get_double(request, "positionX") : mix.positionX;
			const auto positionY = obs_data_has_user_value(request, "positionY") ? obs_data_get_double(request, "positionY") : mix.positionY;
			const auto zoom = obs_data_has_user_value(request, "zoom") ? obs_data_get_double(request, "zoom") : mix.zoom;
			const std::string transitionUuid = obs_data_has_user_value(request, "transitionUuid") ? obs_data_get_string(request, "transitionUuid") : mix.transitionUuid;
			OBSSourceAutoRelease selected = transitionUuid.empty() ? nullptr : obs_get_source_by_uuid(transitionUuid.c_str());
			bool moveLoaded = false; const char* kind; for (size_t n = 0; obs_enum_transition_types(n, &kind); n++) if (std::string(kind) == "move_transition") moveLoaded = true;
			bool busy = mix.transition && obs_transition_is_active(mix.transition);
			if (outputBusy(mixId)) busy = true;
			if (busy) error = "stop Mix 2 outputs before changing framing";
			else if (width < 240 || width > 3840 || height < 240 || height > 3840 || width % 2 || height % 2) error = "invalid Mix 2 resolution";
			else if (!std::isfinite(positionX) || !std::isfinite(positionY) || !std::isfinite(zoom) || positionX < 0 || positionX > 1 || positionY < 0 || positionY > 1 || zoom < 1 || zoom > 4) error = "invalid Mix 2 crop position or zoom";
			else if (transitionUuid == "builtin:move_transition" && !moveLoaded) error = "Move plugin is not loaded; choose Fade or another available transition explicitly";
			else if (!transitionUuid.empty() && transitionUuid != "builtin:move_transition" && (!selected || obs_source_get_type(selected) != OBS_SOURCE_TYPE_TRANSITION || IsPrivateSource(selected))) error = "select a loaded transition";
			else { ClearIndependentTransition(mix); mix.width = width; mix.height = height; mix.fill = fill; mix.positionX = positionX; mix.positionY = positionY; mix.zoom = zoom; mix.transitionUuid = transitionUuid; mix.transitionName = selected ? obs_source_get_name(selected) : ""; if (!mix.programUuid.empty()) EnsureIndependentMix(mix, mixId); }
		} else if (action == "preview") {
			OBSSourceAutoRelease source = obs_get_source_by_uuid(uuid.c_str());
			if (!source || IsPrivateSource(source) || !obs_source_get_width(source)) error = "select a video input outside private director sources";
			else mix.previewUuid = uuid;
		} else if (action == "cut" || action == "fade" || action == "take") {
			if (!EnsureIndependentMix(mix, mixId)) error = "Mix 2 transition unavailable";
			else if (obs_transition_is_active(mix.transition)) error = "Mix 2 transition is already running";
			else if (action == "fade" && std::string(obs_source_get_id(mix.transition)) != "fade_transition") error = "use take for the configured transition";
			else {
				OBSSourceAutoRelease source = obs_get_source_by_uuid(mix.previewUuid.c_str());
				OBSSourceAutoRelease framed = FrameMixSource(mix, source);
				if (!framed) error = "Mix 2 preview has no safe video source";
				else if (action != "cut" && (duration < 50 || duration > 10000)) error = "transition duration must be 50 to 10000 ms";
				else {
					if (action != "cut" && std::string(obs_source_get_id(mix.transition)) == "obs_stinger_transition" && !mix.activeLease) { std::lock_guard<std::mutex> lock(mix.stingerTape->mutex); mix.stingerTape->packets.clear(); mix.stingerTape->clockStarted = false; } obs_source_inc_active(mix.transition); mix.activeLease = true;
					if (action != "cut" && !obs_transition_start(mix.transition, OBS_TRANSITION_MODE_AUTO, duration, framed)) { error = "Mix 2 transition did not start"; if (mix.activeLease) { obs_source_dec_active(mix.transition); mix.activeLease = false; } }
					else { if (action == "cut") obs_transition_set(mix.transition, framed); std::swap(mix.programUuid, mix.previewUuid); }
				}
			}
		} else if (action != "state" && !action.empty()) error = "invalid Mix 2 action";
		if (error.empty() && !action.empty() && action != "state") SaveIndependentMix();
		DescribeMixes(response); obs_data_set_bool(response, "success", error.empty());
		if (!error.empty()) obs_data_set_string(response, "error", error.c_str());
	}

	void ApplyProductionFormat(IndependentMix& mix) {
		obs_video_info canvas{}; if (!obs_get_video_info(&canvas)) return;
		const uint32_t w = canvas.base_width, h = canvas.base_height;
		if (w >= 240 && w <= 3840 && h >= 240 && h <= 3840 && !(w % 2) && !(h % 2)) { mix.width = w; mix.height = h; }
	}

	void RestoreIndependentMixes() {
		for (size_t i = 0; i < independentMixes.size(); i++) {
			auto& mix = independentMixes[i];
			ResolveMixTransition(mix);
			if (mix.transition || mix.programUuid.empty()) continue;
			OBSSourceAutoRelease source = obs_get_source_by_uuid(mix.programUuid.c_str());
			if (!source) continue;
			EnsureIndependentMix(mix, uint32_t(i + 2));
		}
	}

	void SaveIndependentMix() {
		const auto path = ConfigPath(); if (path.empty()) return;
		OBSDataAutoRelease data = obs_data_create(); DescribeMixes(data);
		obs_data_save_json_safe(data, (path + ".mix2.json").c_str(), "tmp", "bak");
	}

	void LoadIndependentMix() {
		for (auto& mix : independentMixes) { ClearIndependentTransition(mix); mix = IndependentMix(); ApplyProductionFormat(mix); }
		const auto path = ConfigPath(); if (path.empty()) return;
		OBSDataAutoRelease data = obs_data_create_from_json_file_safe((path + ".mix2.json").c_str(), "bak"); if (!data) return;
		OBSDataArrayAutoRelease list = obs_data_get_array(data, "mixes");
		for (size_t i = 0; i < independentMixes.size(); i++) {
			OBSDataAutoRelease row = list && i < obs_data_array_count(list) ? obs_data_array_item(list, i) : nullptr; if (!row && i == 0) { row = obs_data_create(); obs_data_apply(row, data); } if (!row) continue; auto& mix = independentMixes[i];
			const auto w = uint32_t(obs_data_get_int(row, "width")), h = uint32_t(obs_data_get_int(row, "height")); if (w >= 240 && w <= 3840 && h >= 240 && h <= 3840 && !(w % 2) && !(h % 2)) { mix.width = w; mix.height = h; }
			mix.fill = obs_data_get_bool(row, "fill"); mix.transitionUuid = obs_data_get_string(row, "transitionUuid"); mix.transitionName = obs_data_get_string(row, "transitionName");
			const double x = obs_data_has_user_value(row, "positionX") ? obs_data_get_double(row, "positionX") : 0.5, y = obs_data_has_user_value(row, "positionY") ? obs_data_get_double(row, "positionY") : 0.5, z = obs_data_has_user_value(row, "zoom") ? obs_data_get_double(row, "zoom") : 1.0;
			mix.positionX = std::isfinite(x) && x >= 0 && x <= 1 ? x : 0.5; mix.positionY = std::isfinite(y) && y >= 0 && y <= 1 ? y : 0.5; mix.zoom = std::isfinite(z) && z >= 1 && z <= 4 ? z : 1.0;
			mix.previewUuid = obs_data_get_string(row, "previewUuid"); mix.programUuid = obs_data_get_string(row, "programUuid");
		}
		RestoreIndependentMixes();
	}

	void Clear() {
		for (auto& mix : independentMixes) {
			ClearIndependentTransition(mix);
			mix.programUuid.clear();
			mix.previewUuid.clear();
		}
	}
};